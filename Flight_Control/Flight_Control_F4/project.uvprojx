# Keil uVision project project.uvprojx, settings and files
target RTThread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\RT-Thread_1.2.0RC\components\dfs;..\..\RT-Thread_1.2.0RC\components\dfs\filesystems\devfs;..\..\RT-Thread_1.2.0RC\components\dfs\include;..\..\RT-Thread_1.2.0RC\components\drivers\include;..\..\RT-Thread_1.2.0RC\components\finsh;..\..\RT-Thread_1.2.0RC\components\init;..\..\RT-Thread_1.2.0RC\include;..\..\RT-Thread_1.2.0RC\libcpu\arm\common;..\..\RT-Thread_1.2.0RC\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c mnttable.c startup.c
  group Drivers
    drivers/: board.c platform.c usart.c ext_sram.c stm32f4xx_it.c sdio_sd.c stm32f20x_40x_spi.c spi_flash_w25qxx.c stm32f4_rtc.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../RT-Thread_1.2.0RC/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../RT-Thread_1.2.0RC/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../RT-Thread_1.2.0RC/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../RT-Thread_1.2.0RC/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/elmfat/option/: ccfile.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    ../../RT-Thread_1.2.0RC/components/drivers/rtc/: rtc.c
    ../../RT-Thread_1.2.0RC/components/drivers/serial/: serial.c
    ../../RT-Thread_1.2.0RC/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RT-Thread_1.2.0RC/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../RT-Thread_1.2.0RC/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Components
    ../../RT-Thread_1.2.0RC/components/init/: components.c
software components: CMSIS:CORE 4.3.0
