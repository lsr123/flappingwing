# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\RT-Thread_1.2.0RC\components\dfs;..\..\RT-Thread_1.2.0RC\components\dfs\filesystems\devfs;..\..\RT-Thread_1.2.0RC\components\dfs\include;..\..\RT-Thread_1.2.0RC\components\drivers\include;..\..\RT-Thread_1.2.0RC\components\finsh;..\..\RT-Thread_1.2.0RC\components\init;..\..\RT-Thread_1.2.0RC\include;..\..\RT-Thread_1.2.0RC\libcpu\arm\common;..\..\RT-Thread_1.2.0RC\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\CoreSupport;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c mnttable.c startup.c
  group Drivers
    drivers/: board.c platform.c stm32f10x_it.c led.c usart.c sdcard.c stm32f10xx_spi.c spi_flash_w25qxx.c stm32f1_rtc.c
    ./drivers/: I2C_soft.c MS5803.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Kernel
    ../../RT-Thread_1.2.0RC/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../RT-Thread_1.2.0RC/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../RT-Thread_1.2.0RC/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../RT-Thread_1.2.0RC/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/elmfat/option/: ccfile.c
    ../../RT-Thread_1.2.0RC/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    ../../RT-Thread_1.2.0RC/components/drivers/rtc/: rtc.c
    ../../RT-Thread_1.2.0RC/components/drivers/serial/: serial.c
    ../../RT-Thread_1.2.0RC/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RT-Thread_1.2.0RC/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../RT-Thread_1.2.0RC/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Components
    ../../RT-Thread_1.2.0RC/components/init/: components.c
software components: CMSIS:CORE 4.3.0
